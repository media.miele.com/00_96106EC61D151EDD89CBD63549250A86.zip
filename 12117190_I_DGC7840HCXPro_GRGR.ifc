Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-08-24T17:57:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Aug 24 17:57:08 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\a0966e0b-436c-4578-948b-8dc13fc44520\e30e6a3a-822d-42bc-8688-d4ba24f303b4\ifc * Database version: 5507 * Database creation date: Wed Aug 24 17:57:07 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Aug 24 17:57:08 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Aug 24 17:57:08 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12117190_I_DGC7840HCXPro_GRGR:23784078_I_12117190_DGC7840HCXPro_GRGR, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel
Type - Pset_BuildingElementProxyCommon - Reference: 23784078_I_12117190_DGC7840HCXPro_GRGR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 23784078_I_12117190_DGC7840HCXPro_GRGR
Type - Pset_ProvisionForVoid - Depth: 569 mm
Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm

# IfcDistributionPort, Port_353505
Description: Flow; FlowDirection: SOURCEANDSINK
